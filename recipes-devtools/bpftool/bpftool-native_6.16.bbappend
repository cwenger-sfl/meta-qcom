FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://bpftool-const-qualifier-gcc15.patch"
